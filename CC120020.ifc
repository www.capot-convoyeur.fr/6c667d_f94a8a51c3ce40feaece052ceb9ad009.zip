Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[AISC_Steel_Detailing, QuantityTakeOffAddOnView], Option [BaseQuantities:On], Option [GridExport:Off], Option [Assemblies:Off], Option [Bolts:On], Option [Rebars:On], Option [PourObjects:Off], Option [Welds:Off], Option [SurfaceTreatments:Off], Option [LocationBy:-2147483648], Option [ViewColors:On], Option [SectionedSpine:Off], Option [PropertySets:On], Option [Export all:Off]
File name: A60.ifc
Time: 2022-09-02T09:39:14
Author: LAPTOP-S15QTADG\gholl
Organization: Structural Designer
Written by: IFC Database version: Work
Made in: Tekla Structures 2021 Service Pack 7, IFC Export Version: 4.0.0.0 Feb 7 2022

# IfcProject, Capot Convoyeur Defrance
AISC_EM11_Pset_ProjectIdentification - Description: Capot Convoyeur Defrance; Project customer: 2022-01

# IfcBuildingStorey, Undefined
In: Undefined
Elevation: 0 mm

# IfcBeam: CC1000-1.50, CC120020
In: Undefined
Description: CC1000-1.50; Material: STEEL/S235JR
AISC_EM11_Pset_PieceIdentification - Treatment: Galvanized; PieceMark: CC120020; IndicationMark: A60; MainPieceTag: yes
AISC_EM11_Pset_Material - MaterialType: STEEL; MaterialGrade: S235JR
AISC_EM11_Pset_SkewedEnd - SkewedAngleY: 0; SkewedAngleX: 0; sets with these values: 2
BaseQuantities - Length: 4369.39 mm; OuterSurfaceArea: 0.0000115503 m2; NetVolume: 0.00374421 m3; NetWeight: 29.3921 kg

# IfcOpeningElement: Opening (4)
In: Undefined
AISC_EM11_Pset_Opening/Cope - FeatureSubTypes: VIS
